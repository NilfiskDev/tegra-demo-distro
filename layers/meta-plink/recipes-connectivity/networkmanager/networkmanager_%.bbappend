PACKAGECONFIG:append = " modemmanager ppp wwan"
