PASSTHRU_ROOT = ""
FILES:${PN} = "/usr"