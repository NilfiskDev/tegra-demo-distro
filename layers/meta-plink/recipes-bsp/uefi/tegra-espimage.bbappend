IMAGE_FSTYPES:forcevariable = "esp tar.gz"
