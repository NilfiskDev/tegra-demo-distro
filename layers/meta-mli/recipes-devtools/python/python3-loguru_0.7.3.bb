SUMMARY = "Fast, Extensible Progress Meter"
LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

PYPI_PACKAGE = "loguru"

inherit pypi python_flit_core
SRC_URI[sha256sum] = "19480589e77d47b8d85b2c827ad95d49bf31b0dcde16593892eb51dd18706eb6"
