DEPENDS += "mesa"

PACKAGECONFIG += "proprietary-codecs"
